# Keil uVision project lab3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab3
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c Thread.c Mutex.c Semaphore.c MsgQueue.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, CMSIS:RTOS:Keil RTX 4.81.1, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:UART 1.2.1, Device:STM32Cube HAL:USART 1.2.1, Device:Startup 2.2.1
